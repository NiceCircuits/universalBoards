File: uni_50mil_v2.brd (EAGLE design)
At the start: 50 x 50 mm, 0 parts

Commit message: Routing and gerbers
Other:
- board size 50 x 50 mm -> 49 x 49.8 mm
